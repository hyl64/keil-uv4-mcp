# Keil uVision project gen_copy.uvprojx, settings and files
target Flash (ARM-ADS)
  device: STM32F103C8 STMicroelectronics:13
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: gen_copy +hex
  c flags: Optim=2 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD
  c include: C:\\Users\\ERDAN.DESKTOP-MVAKHCO\\AppData\\Local\\Arm\\Packs\\Keil\\STM32F1xx_DFP\\2.4.1\\Device\\Include
  memory RVCT4: ROM 0x08000000 size 0x00010000
  memory RVCT9: RAM 0x20000000 size 0x00005000
  group Source
    ./: startup_stm32f10x_md.s system_stm32f10x.c main.c
